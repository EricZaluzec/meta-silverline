
MACHINE_EXTRA_RRECOMENDS += "kernel-module-rtl8723be"


IMAGE_INSTALL = "rtlwifi"

